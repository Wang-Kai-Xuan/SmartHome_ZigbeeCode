<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SmartHome.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>SmartHome</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SmartHome</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SmartHome</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SmartHome</project>
        <configuration>CoordinatorEB-Pro</configuration>
      </member>
      <member>
        <project>SmartHome</project>
        <configuration>RouterEB-Pro</configuration>
      </member>
      <member>
        <project>SmartHome</project>
        <configuration>EndDeviceEB-Pro</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


